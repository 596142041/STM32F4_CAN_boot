# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  AfterMake: fromelf.exe --bin -o $L@H.bin $L@H.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4
  c include: ..\bsp\inc;..\CMSIS\inc;..\CMSIS\asm;..\STM32F4xx_StdPeriph_Driver\inc;..\user\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/src/: main.c user_config.c stm32f4xx_it.c
  group bsp
    ../bsp/src/: delay.c can_driver.c can_bootloader.c Flash.c
  group CMSIS
    ../CMSIS/src/: system_stm32f4xx.c
    ../CMSIS/asm/: startup_stm32f40_41xxx.s
  group Lib
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group Math_Lib
    ../CMSIS/Math_Lib/: IQmathLib-cm4f.lib arm_cortexM4lf_math.lib
